# Keil uVision project IWDG_Reset.uvprojx, settings and files
target N32A003 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A003F5 Nationstech
  pack: Nationstech.N32A003_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0C00) IROM(0x08000000,0x7600) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IWDG_Reset
  AfterMake: fromelf --bin --output=.\bin\IWDG_Reset.bin .\Objects\IWDG_Reset.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32A003, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\inc;..\..\..\..\..\..\firmware\n32a003_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0xc00
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a003.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a003.c
  group FWLB
    ../../../../../../firmware/n32a003_std_periph_driver/src/: misc.c n32a003_dbg.c n32a003_gpio.c n32a003_iwdg.c n32a003_pwr.c n32a003_rcc.c n32a003_uart.c
  group USER
    ../src/: main.c bsp_iwdg.c bsp_led.c n32a003_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DELAY
    ../src/: bsp_delay.c
  group DOC
    ../: readme.txt
