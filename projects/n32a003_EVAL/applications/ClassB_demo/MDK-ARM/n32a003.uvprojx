# Keil uVision project n32a003.uvprojx, settings and files
target N32A003 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A003F5 Nationstech
  pack: Nationstech.N32A003_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0C00) IROM(0x08000000,0x7600) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32A003_SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32A003,USE_STDPERIPH_DRIVER
  c include: ..\N32_SelfTest_Library\inc;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32a003_std_periph_driver\inc;..\..\ClassB_demo
  asm define: ARTISAN=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\N32A003_SelfTest.sct
  group User
    ../: main.c n32a0xx_it.c crc32_software.c
  group CMSIS
    ../../../../../firmware/CMSIS/device/startup/: startup_n32a003.s
    ../../../../../firmware/CMSIS/device/: system_n32a003.c
  group N32_SelfTest_Code
    ./: n32a0xx_STLcpurunKEIL.s n32a0xx_STLcpustartKEIL.s n32a0xx_STLRamMcMxKEIL.s
  group N32_SelfTest_Library
    ../N32_SelfTest_Library/src/: n32a0xx_STLclockrun.c n32a0xx_STLclockstart.c n32a0xx_STLcrc32Run.c n32a0xx_STLmain.c n32a0xx_STLstartup.c n32a0xx_STLtranspRam.c
  group N32A003_Periph
    ../../../../../firmware/n32a003_std_periph_driver/src/: misc.c n32a003_crc.c n32a003_dbg.c n32a003_flash.c n32a003_gpio.c n32a003_iwdg.c n32a003_pwr.c n32a003_rcc.c n32a003_uart.c
